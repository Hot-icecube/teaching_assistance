# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\FWLib\inc;..\User;..\System\usart;..\System\sys;..\System\delay;..\HardWare\LCD;..\HardWare\W25Qxx_SPI_FLASH;..\FatFs\exfuns;..\FatFs\src;..\Malloc;..\TEXT;..\HardWare\RTC;..\HardWare\HC05;..\HardWare\USART3;..\HardWare\USART2;..\HardWare\GBK_LibDrive;..\HardWare\KEY;..\HardWare\TIM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/startup/: startup_stm32f10x_hd.s
  group USER
    ../User/: main.c stm32f10x_it.c
  group HARDWARE
    ../HardWare/LCD/: lcd.c font.c
    ../HardWare/W25Qxx_SPI_FLASH/: w25qxx_spi_flash.c
    ../HardWare/USART3/: usart3.c
    ../HardWare/HC05/: hc05.c
    ../HardWare/GBK_LibDrive/: GBK_LibDrive.c
    ../HardWare/KEY/: key.c
    ../HardWare/TIM/: tim.c
  group SYSTEM
    ../System/usart/: usart.c
    ../System/sys/: sys.c
    ../System/delay/: delay.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MALLOC
    ../Malloc/: malloc.c
  group TEXT
    ../TEXT/: text.c
